# Keil uVision project LittleFOC-0.0.9.uvprojx, settings and files
target LittleFOC-0.0.9 (6190000::V6.19::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LittleFOC-0.0.9 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../LittleFOC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ./: retarget.c
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32g0xx_it.c
  group LittleFOC
    ../LittleFOC/: pmsm_motor.c
  group LittleFOC/common/base_classes
    ../LittleFOC/common/base_classes/: base_vectors.c
  group LittleFOC/common/math_tools
    ../LittleFOC/common/math_tools/: MyMaths.c LPF_controller.c PID_controller.c NI_controller.c
  group LittleFOC/controller
    ../LittleFOC/controller/: FOC_motor.c
  group LittleFOC/driver
    ../LittleFOC/driver/: svpwm_driver.c
  group LittleFOC/sensor
    ../LittleFOC/sensor/: magnetic_sensor.c current_sensor.c
  group README
    ./: README.txt
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_spi.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
