<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_MT6816_20230501.ewp</path>
  </project>
  <batchBuild />
</workspace>
